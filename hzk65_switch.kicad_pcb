File: hzk65_switch.kicad_pcb (KiCad board)
At the start: 2 copper layers, 323.8 x 109.5 mm, 8 parts

Commit message: Update switch plate with new cutout
Other:
- outline, holes or cut-outs redrawn
